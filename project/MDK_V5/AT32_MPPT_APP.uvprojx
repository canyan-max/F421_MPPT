# Keil uVision project AT32_MPPT_APP.uvprojx, settings and files
target AT32_MPPT_APP (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: -AT32F421C8T7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.2.0
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: AT32_MPPT_APP +hex
  AfterMake: ./keil5_disp_size_bar.exe
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=3 wLevel=2
  c define: AT32F421C8T7, USE_STDPERIPH_DRIVER, AT_START_F421_V1
  c include: ..\..\libraries\drivers\inc;..\..\libraries\cmsis\cm4\core_support;..\..\libraries\cmsis\cm4\device_support;..\inc;..\..\00_Project_Config;..\..\03_Platform\comm;..\..\03_Platform\mcu_interface;..\..\03_Platform\bsp;..\..\02_Service;..\..\06_Component\filter
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group firmware
    ../../libraries/drivers/src/: at32f421_crm.c at32f421_tmr.c at32f421_gpio.c at32f421_i2c.c at32f421_usart.c at32f421_pwc.c at32f421_adc.c at32f421_dma.c at32f421_debug.c at32f421_flash.c at32f421_exint.c at32f421_misc.c at32f421_scfg.c
  group cmsis
    ../../libraries/cmsis/cm4/device_support/: system_at32f421.c
    ./: startup_at32f421.s
  group user
    ../src/: at32f421_int.c at32f421_wk_config.c main.c wk_system.c wk_tmr.c wk_gpio.c wk_adc.c wk_dma.c wk_i2c.c wk_usart.c wk_exint.c
  group Platform_Impl
    ../../04_Impl/mcu_at32/: at32f421_gpio_adapter.c at32f421_adc_adapter.c at32f421_pwm_adapter.c at32f421_sys_adapter.c
  group Platform_BSP
    ../../03_Platform/bsp/: bsp_led.c bsp_measure.c bsp_power_path.c
  group Service
    ../../02_Service/: svc_led.c svc_measure.c svc_measure.h svc_discharge.c svc_discharge.h svc_discharge_config.c svc_discharge_config.h svc_discharge_protection.c svc_discharge_protection.h svc_charge.c svc_charge.h svc_charge_diagnostics.c svc_charge_diagnostics.h svc_charge_control.c svc_charge_control.h svc_charge_cc.c svc_charge_cc.h svc_charge_cv.c svc_charge_cv.h svc_charge_maintenance.c svc_charge_maintenance.h svc_charge_mppt.c svc_charge_mppt.h svc_charge_config.c svc_charge_config.h svc_charge_protection.c svc_charge_protection.h
  group Component
    ../../06_Component/filter/: filter.c filter.h
